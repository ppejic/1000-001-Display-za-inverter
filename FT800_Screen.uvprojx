# Keil uVision project FT800_Screen.uvprojx, settings and files
target FT800_SCREEN (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: FT800_Screen
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\SRC\HEADER;.\LIB\HEADER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./SRC/: main.c _init.c events.c _Watchdog.c
    ./SRC/HEADER/: main.h _init.h events.h _Watchdog.h config.h
  group FT800
    ./SRC/: _FT800.c _lcd_controller.c
    ./SRC/HEADER/: _FT800.h _lcd_controller.h
  group CAN
    ./SRC/: _CANReceive.c _CANSend.c
    ./SRC/HEADER/: _CANReceive.h _CANSend.h
  group Device
    ./LIB/SOURCE/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_pwr.c
software components: CMSIS:CORE 3.30.0, CMSIS:RTOS:Keil RTX 4.74.0, Device:Startup 2.4.0
